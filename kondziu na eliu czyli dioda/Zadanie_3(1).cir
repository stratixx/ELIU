D charakterystyka w przewodzeniu
.WIDTH IN=80 OUT=80

*opis uk³adu: Ÿród³o sta³onapiêciowe oraz dioda pó³przewodnikowa
V1 1 0 0.7
D1 1 0 dELIU

*parametry modelu diody
*IS - pr¹d nasycenia
*N - wspó³czynnik emisji
*RS - rezystancja szeregowa
*BV - napiêcie przebicia lawinowego
*IBV - pr¹d przebicia lawinowego
*CJO -  pojemnoœc z³¹cza przy zerowej polaryzacji
*M - wsp. zale¿ny od typy z³¹cza (z³. skokowe =0.5, liniowe =0.33)
*VJ - potencja³ dyfuzyjny z³¹cza pn
*TT - czas przelotu

.MODEL dELIU D IS=8E-15 RS=1 N=1 BV=10  IBV=1.0E-5  CJO=3P M=0.5 VJ=0.7 TT=0.5N

*definicja analizy sta³onapieciowej oraz zmian N
.DC V1 0.0001 0.85 0.01 LIN D dELIU(N) 1 2 0.5

*Zapis do zbioru wyjsciowego
.print DC I(D1)

*punkt pracy
.OP

.OPTIONS NOPAGE
.PROBE
.END
